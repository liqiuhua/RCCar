# Keil uVision project RC.uvprojx, settings and files
target RC (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: RCCar +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,__TARGET_FPU_VFP
  c include: ../Core/Inc;..\Drivers\STM32F4xx_StdPeriph_Driver\inc;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\User;..\FreeRTOSv10.2.1\FreeRTOS\Source\include;..\FreeRTOSv10.2.1\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\User\TFTLCD;..\User\FreeRTOS_Debug;..\User\RC;..\Drivers\CMSIS\DSP\Include;..\Drivers\STemWinLibrary532\Config;..\Drivers\STemWinLibrary532\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f4xx_it.c
    ../User/: ExceptionHandler.c ExceptionHandler.h
  group Drivers/STM32F4xx_STD_Driver
    ../Drivers/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Drivers/CMSIS/DSP
    ../Drivers/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
    ../Drivers/CMSIS/DSP/Include/: arm_math.h
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Mid/STemWinConfig
    ../Drivers/STemWinLibrary532/Config/: GUIConf.c GUIDRV_Template.c LCDConf_FlexColor_Template.c
    ../Drivers/STemWinLibrary532/OS/: GUI_X_FreeRTOS.c
  group Mid/STemWinLIb
    ../Drivers/STemWinLibrary532/Lib/: STemWin532_CM4_OS_Keil.lib
  group Mid/FreeRTOS_core
    ../FreeRTOSv10.2.1/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Mid/FreeRTOS_Portable
    ../FreeRTOSv10.2.1/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../FreeRTOSv10.2.1/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Driver/TFTLCD
    ../User/TFTLCD/: TFTLCD.h TFTLCD.c GUI_X_touch.c GUI_X_touch.h
  group Driver/SystemDebug
    ../User/FreeRTOS_Debug/: FreeRTOS_Debug.c FreeRTOS_Debug.h
  group Driver/RC
    ../User/RC/: RC.c RC.h
    ../User/: PWM.h PWM.c KEY.c KEY.h
software components: CMSIS:CORE 5.2.0
